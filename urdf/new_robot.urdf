Commit message: feat: 添加三轴机器人模型及其关节配置

File: urdf/new_robot.urdf (robot description, URDF)
Before this commit: robot three_axis_robot, 5 links, 4 joints
Joints:
- joint wrist_1_joint: axis 0 1 0 -> 0 0 1
- joint wrist_2_joint: axis 0 0 1 -> 0 1 0
